Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-04-26T19:59:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 26 19:59:34 2023 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\fc7c76c3-978b-4794-b870-f55311e05b5c\3ba2909e-3c5a-4c0e-808a-a6820970f831\ifc * Database version: 5507 * Database creation date: Wed Apr 26 19:59:33 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 26 19:59:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 26 19:59:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: FFAST702-000500BF0_REVIT:Winston Wall Tap (Cross Handle), FFAST702-000500BF0_REVIT:Winston Wall Tap (Cross Handle):347185
In: Level 1
Pset_DistributionFlowElementCommon - Reference: Winston Wall Tap (Cross Handle); sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_ProductRequirements - Category: Plumbing Fixtures
